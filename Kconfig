## Kconfig
```kconfig
config RTL8852BS
	tristate "Realtek 8852B SDIO support"
	depends on WLAN && MMC && CFG80211
	default m
	help
	This option enables support for RTL8852BS SDIO drivers
```
